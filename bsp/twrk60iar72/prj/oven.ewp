# IAR project oven.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __ARM_CM4FIAR7_2__
  ICCARM.CCIncludePath2: ..\..\twrk60iar72; ..\..\twrk60iar72\cm4f; ..\..\twrk60iar72\switch; ..\..\..\oven_1\; ..\..\..\..\rkh\source\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: oven.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group bsp
    ../: bsp.c bsp.h gpio.h kuart.c kuart.h mytypes.h
  group bsp/cm4f
    ../cm4f/: arm_cm4.c arm_cm4.h cpu.c cpu.h derivative.h MCUinit.c MCUinit.h MK60D10.h
  group bsp/switch
    ../switch/: swhdl.c swhdl.h switch.c switch.h
  group oven
    ../../../oven_1/: main.c oven.c oven.h ovenact.c ovenact.h ovenevt.h rkhcfg.h
  group rkh/source
    ../../../../rkh/source/: rkh.c rkhdyn.c rkhmp.c rkhrq.c rkhs.c rkhsma.c rkhtbl.c rkhtim.c rkhtrc.c
  group rkh/source/include
    ../../../../rkh/source/include/: rkh.h rkhassert.h rkhdef.h rkhevt.h rkhitl.h rkhmp.h rkhplat.h rkhrdy.h rkhrq.h rkhs.h rkhtim.h rkhtrc.h rkhtype.h
  group rkh/source/portable
    ../../../../rkh/source/portable/arm-cortex/rkhs/arm_cm4f/iar_v7_2/: rkhport.c rkhport.h rkht.h
